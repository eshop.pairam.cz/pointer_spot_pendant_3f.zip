Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Pointer spot pendant 3F.IFC
Time: 2024-09-02T07:53:17
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Pointer spot pendant 3F
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
